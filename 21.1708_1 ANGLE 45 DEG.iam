# Autodesk Inventor assembly: 21.1708_1 ANGLE 45 DEG
## iProperties
Created: 2007-01
Part Number: 21.1708_1 ANGLE 45 DEG
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
